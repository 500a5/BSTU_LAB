	ORG 0
	ANL TMOD,#11110000B
	ORL TMOD,#00000000B
	CRL RS0
	CRL RS1
	SETB P1.4
	CLR P1.5
	MOV R0,#0;20 ПЕРИОДОВ ПО 10C
M1:	MOV R1,#0
	MOV A,#20
	SUBB A,R0
	MOV R2,A
	SETB A,R0
	MOV R2,A
	SETB P1.7
	CLR P1.6
	JMP M6
M5:	MOV TH0,#09EH
	MOV TL0,#057H
	SETB TR0
M8:	JNB TF0,M8
	CLR TR0
	CLR TF0
	DEC R2
M6:	CJNE R2,#0,M5

M2: 	MOV A,RO
	MOV R2,A
	CLR P1.7
	SETB P1.6
	JMP M4
M3:	MOV TH0,#09EH
	MOV TL0,#057H
	SETB TR0 
M7:	JNB TF0,M7
	CLR TR0
	CLR TF0
	DEC R2
M4:	CJNE R2,#0,M3

	INC R1
	CJNE R1,#200,M2
	INC R0
	CJNE R0,#10,M1
	SETB P1.7
	CLR P1.6
	JMP $
END
